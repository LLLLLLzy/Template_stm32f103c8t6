# Keil uVision project Temlate.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CODE\STM32F10x_FWLib\inc;..\CODE\CORE;..\CODE\USER;..\CODE\APP;..\CODE\BSP;..\CODE\SYSTEM\delay;..\CODE\SYSTEM\sys
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../CODE/USER/: main.c
  group BSP
    ../CODE/BSP/: bsp.c gpio.c
  group CORE
    ../CODE/CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group SYSTEM
    ../CODE/SYSTEM/delay/: delay.c
  group FWLIB
    ../CODE/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
software components: CMSIS:CORE 5.2.0
